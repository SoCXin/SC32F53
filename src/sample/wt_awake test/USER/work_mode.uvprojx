# Keil uVision project work_mode.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: SC32F53128 SILAN
  pack: Keil.SC32F53xx_DFP.1.0.4
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stop_mode
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\USER;..\..\Drivers\SC32F53128_FWLib\src;..\..\Drivers\SC32F53128_FWLib\inc;..\CODE\bsp
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c sc32f53xx_it.c
  group SC32F53128_FWLib
    ../../Drivers/SC32F53128_FWLib/src/: misc.c sc32f53xx_clock.c sc32f53xx_gpio.c sc32f53xx_wt.c sc32f53xx_system.c
  group CODE
    ../CODE/bsp/: bsp_clock.c bsp_gpio.c bsp_wt.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
